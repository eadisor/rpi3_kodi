
IMAGE_INSTALL += "\
	dhcp-client \
	wpa-supplicant \
"
